# Keil uVision project ecg_afe.uvprojx, settings and files
target nrf52840_xxaa (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_CUSTOM CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h> NRF52840_XXAA NRF_CRYPTO_MAX_INSTANCE_COUNT=1 __HEAP_SIZE=4096 __STACK_SIZE=1024 CONFIG_NFCT_PINS_AS_GPIOS
  c misc: --reduce_paths
  c include: .\;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_advertising;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_dtm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_link_ctx_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_racp;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ancs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ans_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_bas;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_bas_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_cscs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_cts_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_dfu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_dis;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_gls;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hids;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hrs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hrs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hts;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ias;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ias_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_lbs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_lbs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_lls;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_nus;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_nus_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_rscs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_rscs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_tps;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\common;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\nrf_ble_gatt;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\nrf_ble_qwr;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\peer_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\nrf_ble_gq;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\boards;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\atomic;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\atomic_fifo;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\atomic_flags;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\balloc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\bootloader\ble_dfu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\bsp;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\button;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\cli;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crc16;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crc32;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\csense;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\csense_drv;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\delay;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\ecc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\experimental_section_vars;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\experimental_task_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\fds;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\fifo;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\fstorage;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\gfx;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\gpiote;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\hardfault;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\hardfault\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\hci;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\led_softblink;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\log;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\log\src;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\low_power_pwm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\mem_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\memobj;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\mpu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\mutex;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\pwm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\pwr_mgmt;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\queue;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\ringbuf;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\scheduler;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\sdcard;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\slip;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\sortlist;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\spi_mngr;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\stack_guard;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\strerror;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\svc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\timer;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\twi_mngr;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\twi_sensor;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\uart;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\audio;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\cdc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\cdc\acm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid\generic;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid\kbd;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid\mouse;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\msc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\util;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ac_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\common;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\hs_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\le_oob_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\generic\message;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\generic\record;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\launchapp;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\parser\message;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\parser\record;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\text;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\uri;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t2t_lib;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t2t_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_lib;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\apdu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\cc_file;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\hl_detection_procedure;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\tlv;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\softdevice\common;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\softdevice\s140\headers;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\softdevice\s140\headers\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\fprintf;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\freertos\portable\ARM\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\freertos\portable\CMSIS\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\freertos\source\include;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\segger_rtt;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\utf_converter;..\..\sdk\nrf5_sdk_17.0.2_d674dde\integration\nrfx;..\..\sdk\nrf5_sdk_17.0.2_d674dde\integration\nrfx\legacy;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx\drivers\include;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx\hal;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx\mdk;..\config;..\fonts;..\gfx;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_db_discovery;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\nrf_ble_scan;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\cc310;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\oberon;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\nrf_hw;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\mbedtls;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\mbedtls\include;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\nrf_cc310\include;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\nrf_oberon;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\nrf_oberon\include;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\cc310_bl;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\cifra;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\micro_ecc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\nrf_sw;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto\backend\optiga;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\stack_info;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\nrf_oberon\lib\cortex-m4\hard-float\short-wchar;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\nrf_cc310\lib\cortex-m4\hard-float\short-wchar;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\mbedtls\library;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\queue;..\AMS;..\fonts;..\percepio;..\mlx90632_lib;..\nova_heart_rate
  asm define: BOARD_CUSTOM CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT NRF52840_XXAA NRF_CRYPTO_MAX_INSTANCE_COUNT=1 __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS
  asm misc: --cpreproc_opts=-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\sdk\nrf5_sdk_17.0.2_d674dde\components;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_advertising;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_dtm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_link_ctx_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_racp;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ancs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ans_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_bas;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_bas_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_cscs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_cts_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_dfu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_dis;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_gls;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hids;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hrs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hrs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_hts;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ias;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_ias_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_lbs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_lbs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_lls;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_nus;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_nus_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_rscs;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_rscs_c;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\ble_services\ble_tps;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\common;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\nrf_ble_gatt;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\nrf_ble_qwr;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\ble\peer_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\boards;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\atomic;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\atomic_fifo;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\atomic_flags;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\balloc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\bootloader\ble_dfu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\bsp;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\button;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\cli;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crc16;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crc32;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\crypto;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\csense;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\csense_drv;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\delay;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\ecc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\experimental_section_vars;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\experimental_task_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\fds;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\fifo;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\fstorage;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\gfx;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\gpiote;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\hardfault;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\hardfault\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\hci;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\led_softblink;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\log;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\log\src;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\low_power_pwm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\mem_manager;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\memobj;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\mpu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\mutex;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\pwm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\pwr_mgmt;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\queue;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\ringbuf;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\scheduler;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\sdcard;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\slip;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\sortlist;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\spi_mngr;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\stack_guard;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\strerror;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\svc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\timer;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\twi_mngr;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\twi_sensor;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\uart;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\audio;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\cdc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\cdc\acm;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid\generic;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid\kbd;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\hid\mouse;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\usbd\class\msc;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\libraries\util;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ac_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\common;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\hs_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\connection_handover\le_oob_rec;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\generic\message;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\generic\record;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\launchapp;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\parser\message;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\parser\record;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\text;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\ndef\uri;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t2t_lib;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t2t_parser;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_lib;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\apdu;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\cc_file;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\hl_detection_procedure;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\nfc\t4t_parser\tlv;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\softdevice\common;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\softdevice\s140\headers;..\..\sdk\nrf5_sdk_17.0.2_d674dde\components\softdevice\s140\headers\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\fprintf;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\freertos\config;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\freertos\portable\ARM\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\freertos\portable\CMSIS\nrf52;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\freertos\source\include;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\segger_rtt;..\..\sdk\nrf5_sdk_17.0.2_d674dde\external\utf_converter;..\..\sdk\nrf5_sdk_17.0.2_d674dde\integration\nrfx;..\..\sdk\nrf5_sdk_17.0.2_d674dde\integration\nrfx\legacy;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx\drivers\include;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx\hal;..\..\sdk\nrf5_sdk_17.0.2_d674dde\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xc0000
  memory RVCT9: RAM 0x20003be0 size 0x3c420
  link misc: --diag_suppress 6330
  group Application
    ../: main.c settings.h errors.h custom_board.h board_v1-0.h sys.c spim_freertos.c logger_freertos.c ble_advdata.c debug_monitor.c ads129x.c
    ../config/: sdk_config.h FreeRTOSConfig.h
  group Third Parties
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/freertos/portable/ARM/nrf52/: port.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/freertos/source/portable/MemMang/: heap_4.c
  group UTF8/UTF16 converter
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/utf_converter/: utf.c
  group nRF_BLE
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/ble_advertising/: ble_advertising.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/common/: ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c nrf_ble_lesc.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/nrf_ble_gq/: nrf_ble_gq.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/nrf_ble_scan/: nrf_ble_scan.c
  group nRF_BLE_Services
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/ble_services/ble_nus/: ble_nus.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/ble/ble_services/ble_nus_c/: ble_nus_c.c
  group nRF_Drivers
    ../../sdk/nrf5_sdk_17.0.2_d674dde/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_ppi.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/modules/nrfx/soc/: nrfx_atomic.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_power.c nrfx_systick.c nrfx_ppi.c nrfx_timer.c nrfx_qspi.c nrfx_wdt.c
  group nRF_Libraries
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/fifo/: app_fifo.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/timer/: app_timer_freertos.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/hardfault/: hardfault_implementation.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/atomic_flags/: nrf_atflags.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/atomic/: nrf_atomic.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/balloc/: nrf_balloc.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/memobj/: nrf_memobj.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/strerror/: nrf_strerror.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/fds/: fds.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
  group nRF_Crypto
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_shared.c
    ../: nrf_crypto_rng.c
  group nRF_Crypto_backend CC310
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/crypto/backend/cc310/: cc310_backend_aes.c cc310_backend_aes_aead.c cc310_backend_chacha_poly_aead.c cc310_backend_ecc.c cc310_backend_ecdh.c cc310_backend_ecdsa.c cc310_backend_eddsa.c cc310_backend_hash.c cc310_backend_hmac.c cc310_backend_init.c cc310_backend_mutex.c cc310_backend_rng.c cc310_backend_shared.c
  group nRF_Crypto_backend Oberon
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto_backend nRF HW
    ../../sdk/nrf5_sdk_17.0.2_d674dde/components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_Oberon_Crypto
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.6.lib
  group nRF_cc310
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/nrf_cc310/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_0.9.13.lib
  group nRF_TLS
    ../../sdk/nrf5_sdk_17.0.2_d674dde/external/mbedtls/library/: aes.c ctr_drbg.c platform_util.c
target flash_s140_nrf52_7.2.0_softdevice (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002a98 size 0x3d568
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
